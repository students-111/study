# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3507_nortos_keil (6240000::V6.24::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "$Psyscfg_keil.bat"
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: C:\TI\mspm0_sdk_2_11_00_07\source\third_party\CMSIS\Core\Include;C:\TI\mspm0_sdk_2_11_00_07\source;..;../User/APP;../User/DAL;../User/Driver;../User/BSP;../User/CPU;../User/Arithmetic;../User/Test
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: C:\TI\mspm0_sdk_2_11_00_07\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group Source
    ../User/APP/: app_task4.c app_task4.h
    ../: empty.c empty.syscfg include.h ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g350x_uvision.s
  group User/CPU
    ../User/CPU/: MultiTimer.c MultiTimer.h scheduler.c scheduler.h
  group User/APP
    ../User/APP/: app.c app.h app_drive_mode.c app_drive_mode.h app_line_follow.c app_line_follow.h app_straight_drive.c app_straight_drive.h
  group User/DAL
    ../User/DAL/: dal_encoder.c dal_encoder.h dal_motor.c dal_motor.h dal_gray.c dal_gray.h dal_key.c dal_key.h dal_jy901p.c dal_jy901p.h dal_pid.c dal_pid.h
  group User/BSP
    ../User/BSP/: bsp_encoder.c bsp_encoder.h bsp_board.c bsp_board.h bsp_i2c.c bsp_i2c.h bsp_pwm.c bsp_pwm.h bsp_status.h bsp_time.c bsp_time.h bsp_uart.c bsp_uart.h
  group User/Driver
    ../User/Driver/: drv_encoder.c drv_encoder.h drv_motor.c drv_motor.h
  group User/Test
    ../User/Test/: test_motor_pwm.c test_motor_pwm.h test_gray.c test_gray.h test_speed_loop.c test_speed_loop.h
  group User/Arithmetic
    ../User/Arithmetic/: PID.c PID.h ringbuffer.c ringbuffer.h
